PROCESSOR 16f877
INCLUDE <p16f877.inc>
R1 equ H'26'
CONST equ H'27'
STATUS equ H'03'
ORG 0
 GOTO INICIO 
 ORG 5
INICIO: MOVLW  H'00'
		MOVWF R1
		MOVLW  H'07'
		MOVWF CONST
LOOP: 
		MOVF R1, w
		SUBLW H'09'
		BTFSC STATUS, 2
		GOTO SUMA_CONST
		MOVF R1, w
		SUBLW H'19'
		BTFSC STATUS, 2
		GOTO SUMA_CONST
		MOVF R1, w
		SUBLW H'20'
		BTFSC STATUS, 2
		GOTO SET_ZERO
		INCF R1
 		GOTO LOOP
SUMA_CONST:
		MOVF CONST, w
		ADDWF R1
		GOTO LOOP
SET_ZERO:
		MOVLW H'00'
		MOVWF R1
		GOTO LOOP
 END