PROCESSOR 16f877
INCLUDE <p16f877.inc>
R1 equ H'26'
CONST equ H'27'
STATUS equ H'03'
ORG 0
 GOTO INICIO 
 ORG 5
INICIO: MOVLW  H'00'
		MOVWF R1
		MOVLW  H'07'
		MOVWF CONST
LOOP: 
		INCF R1
		MOVF R1, w
		ANDLW H'09'
		BTFSC STATUS, 2
		GOTO SUMA_CONST
		ANDLW H'19'
		BTFSC STATUS, 2
		GOTO SUMA_CONST
		ANDLW H'20'
		BTFSC STATUS, 2
		GOTO SET_ZERO
 GOTO LOOP
SUMA_CONST:
		MOVWF CONST
		ADDWF R1
		GOTO LOOP
SET_ZERO:
		MOVLW H'00'
		MOVWF R1
		GOTO LOOP
 END