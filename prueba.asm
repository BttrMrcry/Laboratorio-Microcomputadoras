PROCESSOR 16f877
INCLUDE <p16f877.inc>
J equ H'26'
K equ H'27'
R1 equ H'29'
C1 equ H'28'
STATUS equ H'03'
		ORG 0
		GOTO INICIO
		ORG 5
INICIO: MOVF K,W
		ADDWF J,0
		MOVWF R1
		BTFSC STATUS, 0
		GOTO C_1
		GOTO C_0
	C_0: 
		MOVLW H'00'
		MOVWF C1
		GOTO RESUME
	C_1: 
		MOVLW H'01'
		MOVWF C1
		GOTO RESUME
RESUME:
		GOTO INICIO
		END




	